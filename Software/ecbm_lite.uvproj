# Keil uVision project ecbm_lite.uvproj, settings and files
target STC8 (MCS-51)
  device: STC8H1K08 Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0x03FF) IROM(0-0x1FF8) CLOCK(35000000) MODP2
  output: ecbm_lite +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\ECBM_LIB;.\device\new_test;.\device\proj;.\device
  link misc: REMOVEUNUSED
  group USER
    ./: STARTUP.A51 main.c
  group LIB_LIST
    ./ECBM_LIB/: ecbm_core.h gpio.h power.h uart.h exti.h timer.h eeprom.h spi.h soft_spi.h iic.h soft_iic.h adc.h cmp.h mdu16.h pca.h pwm.h ecbm_reg.h lcm.h
    $TC_ROOT$/../../Users/Patrick/Downloads/MCU/ecbm-library-lite-master/device/: ST7567.h
  group ECBM_LIB
    ./ECBM_LIB/: ecbm_core.c gpio.c power.c uart.c exti.c timer.c eeprom.c spi.c soft_spi.c iic.c soft_iic.c adc.c cmp.c mdu16.c pca.c pwm.c lcm.c
  group DEVICE
    ./device/: ST7567.c
    ../../../MCU/ecbm-library-lite-master/device/: ST7567.h
    ./: EC11.c EC11.h DS1302.c DS1302.h
